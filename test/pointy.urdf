Commit message: added new tests for eef controller

File: test/pointy.urdf (robot description, URDF)
Before this commit: robot pointy, 4 links, 3 joints
Joints:
- joint joint_x: type revolute -> prismatic
- joint joint_y: type revolute -> prismatic
- joint joint_z: type revolute -> prismatic
